# IAR project DISCOVER.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH; DEBUGxx
  ICCARM.PreInclude: stm32f0xx_conf.h
  ICCARM.CCIncludePath2: ; src\EvalTest; ..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DISCOVER.hex
  ILINK.IlinkOutputFile: DISCOVER.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SILICON_CHIP; VECT_TAB_RAM
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: stm32f0xx_ram.icf
  group EvBoard
    src/EvalTest/: beep.c beep.h blacklight.c blacklight.h i2c.c i2c.h key.c key.h lcd_der.h main.c main.h spi.c spi.h stm32f0xx_conf.h system_stm32f0xx.c timer.c timer.h touch.c touch.h uart.c uart.h
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: lcd_der.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group Lib
    ../Libraries/CMSIS/Include/: core_cm0.h
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c
    src/EvalTest/: stm32f0xx_it.c
